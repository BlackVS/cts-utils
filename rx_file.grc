options:
  parameters:
    author: vvs
    generate_options: qt_gui
    id: rx_file
    output_language: python
    title: Simple receiver or test.raw file
  states: {}

blocks:
- name: freq_carrier
  id: variable
  parameters:
    value: '400000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: server_address
  id: variable
  parameters:
    value: server_address_format % (server_ip, server_port) if server_address_format != "" else ""
  states: {}
- name: server_address_format
  id: variable_config
  parameters:
    config_file: config_file
    option: '"server_address_format"'
    section: '"main"'
    type: string
    value: '"tcp://%s:%d"'
    writeback: None
  states: {}
- name: server_bw_per_port
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: server_port
  id: variable
  parameters:
    value: int(server_port_base + (freq_carrier / server_bw_per_port))
  states: {}
- name: server_port_base
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: server_ip
  id: parameter
  parameters:
    label: Server IP
    type: str
    value: '"127.0.0.1"'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: server_address
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}

connections:
- [zeromq_sub_source_0, '0', blocks_tag_debug_0, '0']
- [zeromq_sub_source_0, '0', qtgui_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
